# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries; Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: C:\Users\Happy\Desktop\test\Libraries\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARM
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group FRAM
    Libraries/: FRAM.c
  group GUI
    Libraries/: GLCD.c GuiObject.c Gulim10_8x16_ASCII.c Gulim20_16x34_ASCII.c Gulim28_24x48_ASCII.c Gulim7_6x10_ASCII.c Gulim8_8x12_ASCII.c ILI9163B.c
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
  group User
    ./: 0608_E1_S.c 0608_E2_S.c 0608GPIO_JoyStick.c 1_HW6_2015134022_송진한 .c 1_HW8_1.c 20200608E1.c EXTINT_0525.c GPIO_KeyScan(student)0427.c GPIO_LED.c GPIO_SW(Student)0427.c
    마이컴구조2020_FRAM/: FRAM_main.c
    ../마이컴8주차_대면수업/: GLCD_Display(문자_그림).c
    Libraries/: Util.c
